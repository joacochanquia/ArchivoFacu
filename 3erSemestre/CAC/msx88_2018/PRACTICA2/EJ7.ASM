	ORG 	1000H
MSJ 	DB 	"INGRESE UN NUMERO:"
FIN_M 	DB 	?
MSJ2 	DB 	"CARACTER NO VALIDO"
FIN_M2 	DB 	?
	ORG 	1500H
NUM1 	DB 	?
NUM2	DB	?
RES	DB	?
	DB	?
	ORG	3000H
SUMA:	SUB	CL, 30H
	SUB	CH, 30H
	MOV	DH, 30H
	ADD	DH, CL
	ADD	DH, CH
	CMP	DH, 3AH
	JNS	DIG2
	MOV 	BX, OFFSET RES
	MOV 	DL, 30H
	MOV	[BX], DL
	INC	BX
	MOV	[BX], DH
	JMP	FIN_S
DIG2:	MOV 	BX, OFFSET RES
	MOV 	DL, 31H
	MOV	[BX], DL
	INC	BX
	SUB	DH, 0AH
	MOV	[BX], DH
FIN_S:	RET
	ORG 	2000H
	MOV 	BX, OFFSET MSJ
	MOV 	AL, OFFSET FIN_M-OFFSET MSJ
	INT 	7
	MOV 	BX, OFFSET NUM1
	INT 	6
	MOV 	AL, 1
	INT 	7
;CARGO NUM1
	MOV 	BX, OFFSET MSJ
	MOV 	AL, OFFSET FIN_M-OFFSET MSJ
	INT 	7
	MOV 	BX, OFFSET NUM2
	INT 	6
	MOV 	AL, 1
	INT 	7
;CARGO NUM2
	MOV 	CL, NUM1
	MOV	CH, NUM2
	CALL	SUMA
	MOV 	BX, OFFSET RES
	MOV 	AL, 2
	INT 	7
FIN:	INT	0
	END
