	ORG 	1000H
MSJ 	DB 	"INGRESE UN NUMERO:"
FIN_M 	DB 	?
MSJ2 	DB 	"CARACTER NO VALIDO"
FIN_M2 	DB 	?
	ORG 	1500H
NUM1 	DB 	?
NUM2	DB	?
RES	DB	?
	DB	?
	ORG	3000H
RESTA:	SUB	CH, 30H
	MOV	DH, CL
	SUB	DH, CH
	CMP	DH, 30H
	JNS	POS
	MOV 	BX, OFFSET RES
	MOV 	DL, 45   ; SIGNO -
	MOV	[BX], DL
	INC	BX
	MOV	DL, 30H
	SUB	DL, DH
	MOV	DH, 30H
	ADD	DH, DL
	MOV	[BX], DH
	JMP	FIN_S
POS:	MOV 	BX, OFFSET RES
	MOV 	DL, 43   ; SIGNO +
	MOV	[BX], DL
	INC	BX
	MOV	[BX], DH
FIN_S:	RET
	ORG 	2000H
	MOV 	BX, OFFSET MSJ
	MOV 	AL, OFFSET FIN_M-OFFSET MSJ
	INT 	7
	MOV 	BX, OFFSET NUM1
	INT 	6
	MOV 	AL, 1
	INT 	7
;CARGO NUM1
	MOV 	BX, OFFSET MSJ
	MOV 	AL, OFFSET FIN_M-OFFSET MSJ
	INT 	7
	MOV 	BX, OFFSET NUM2
	INT 	6
	MOV 	AL, 1
	INT 	7
;CARGO NUM2
	MOV 	CL, NUM1
	MOV	CH, NUM2
	CALL	RESTA
	MOV 	BX, OFFSET RES
	MOV 	AL, 2
	INT 	7
FIN:	INT	0
	END
