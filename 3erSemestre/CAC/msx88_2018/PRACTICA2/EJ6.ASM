	ORG 	1000H
MSJ 	DB 	"INGRESE UN NUMERO:"
FIN_M 	DB 	?
MSJ0 	DB 	"CERO"
FIN_M0 	DB 	?
MSJ1 	DB 	"UNO"
FIN_M1 	DB 	?
MSJ2 	DB 	"DOS"
FIN_M2 	DB 	?
MSJ3 	DB 	"TRES"
FIN_M3 	DB 	?
MSJ4 	DB 	"CUATRO"
FIN_M4 	DB 	?
MSJ5 	DB 	"CINCO"
FIN_M5 	DB 	?
MSJ6 	DB 	"SEIS"
FIN_M6 	DB 	?
MSJ7 	DB 	"SIETE"
FIN_M7 	DB 	?
MSJ8 	DB 	"OCHO"
FIN_M8 	DB 	?
MSJ9 	DB 	"NUEVE"
FIN_M9 	DB 	?
MSJNO 	DB 	"CARACTER NO VALIDO"
FIN_MNO DB 	?
	ORG 	1500H
NUM 	DB 	?

	ORG	3000H
IMP_NUM:CMP	CL, 30H
	JZ	IMP_0
	CMP	CL, 31H
	JZ	IMP_1
	CMP	CL, 32H
	JZ	IMP_2
	CMP	CL, 33H
	JZ	IMP_3
	CMP	CL, 34H
	JZ	IMP_4
	CMP	CL, 35H
	JZ	IMP_5
	CMP	CL, 36H
	JZ	IMP_6
	CMP	CL, 37H
	JZ	IMP_7
	CMP	CL, 38H
	JZ	IMP_8
	CMP	CL, 39H
	JZ	IMP_9
	MOV 	BX, OFFSET MSJNO
	MOV 	AL, OFFSET FIN_MNO-OFFSET MSJNO
	INT 	7
	JMP	FIN_SUB
IMP_0:	MOV 	BX, OFFSET MSJ0
	MOV 	AL, OFFSET FIN_M0-OFFSET MSJ0
	INT 	7
	JMP	FIN_SUB
IMP_1:	MOV 	BX, OFFSET MSJ1
	MOV 	AL, OFFSET FIN_M1-OFFSET MSJ1
	INT 	7
	JMP	FIN_SUB
IMP_2:	MOV 	BX, OFFSET MSJ2
	MOV 	AL, OFFSET FIN_M2-OFFSET MSJ2
	INT 	7
	JMP	FIN_SUB
IMP_3:	MOV 	BX, OFFSET MSJ3
	MOV 	AL, OFFSET FIN_M3-OFFSET MSJ3
	INT 	7
	JMP	FIN_SUB
IMP_4:	MOV 	BX, OFFSET MSJ4
	MOV 	AL, OFFSET FIN_M4-OFFSET MSJ4
	INT 	7
	JMP	FIN_SUB
IMP_5:	MOV 	BX, OFFSET MSJ5
	MOV 	AL, OFFSET FIN_M5-OFFSET MSJ5
	INT 	7
	JMP	FIN_SUB
IMP_6:	MOV 	BX, OFFSET MSJ6
	MOV 	AL, OFFSET FIN_M6-OFFSET MSJ6
	INT 	7
	JMP	FIN_SUB
IMP_7:	MOV 	BX, OFFSET MSJ7
	MOV 	AL, OFFSET FIN_M7-OFFSET MSJ7
	INT 	7
	JMP	FIN_SUB
IMP_8:	MOV 	BX, OFFSET MSJ8
	MOV 	AL, OFFSET FIN_M8-OFFSET MSJ8
	INT 	7
	JMP	FIN_SUB
IMP_9:	MOV 	BX, OFFSET MSJ9
	MOV 	AL, OFFSET FIN_M9-OFFSET MSJ9
	INT 	7
	JMP	FIN_SUB
FIN_SUB:	RET

	ORG 	2000H
LAZO:	MOV 	BX, OFFSET MSJ
	MOV 	AL, OFFSET FIN_M-OFFSET MSJ
	INT 	7
	MOV 	BX, OFFSET NUM
	INT 	6
	MOV 	AL, 1
	INT 	7
	MOV 	CL, NUM
; SI CL ES != 0
	CMP	CL, 30H
	JNZ	NO_0
; SI YA HABIA PASADO POR UN 0 ANTES
	CMP 	AH, 01H
	JZ 	FIN
; SI ES 0 TENGO QUR AVISAR QUE PASE POR UN 0
	MOV	AH, 01H
	JMP	SUBR
; SI NO ES 0 RESETEO EL AVISO
NO_0:	MOV	AH, 00H
SUBR:	CALL	IMP_NUM
	JMP	LAZO
FIN:	INT 	0
	END
