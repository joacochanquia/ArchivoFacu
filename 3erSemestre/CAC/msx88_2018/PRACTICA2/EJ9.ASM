	ORG 	1000H
CLAVE 	DB  	"****"
CLADEF	DB  	"8899"
MSJ 	DB 	"INGRESE LA CLAVE:"
FIN_M 	DB 	?
PERM	DB 	"Acceso permitido"
FIN_PE	DB 	? 
DENEG	DB 	"Acceso denegado" 
FIN_DE	DB 	?
	
	ORG	3000H
CONTRA:	MOV 	DH, 4
	MOV 	BX, OFFSET CLAVE ;direccion de la clave 	
INCLAV:	INT 	6 
	INC 	BX 
	DEC 	DH
	JNZ 	INCLAV 	
	MOV	AX, OFFSET CLADEF
	MOV	CX, OFFSET CLAVE
	MOV	DH, 4
LAZO:	MOV	DL, [BX]
	INC	CX
	MOV	BX, AX
; COMPARO AMBOS VALORES
	CMP	[BX], DL
	JNZ	NO_VAL
	INC 	AX
	MOV	BX, CX
	DEC	DH
	JNZ	LAZO
	MOV	DH, 0FFH
	JMP	FIN_S
NO_VAL:	MOV	DH, 00H
FIN_S:	RET
	
	ORG 	2000H
	MOV 	BX, OFFSET MSJ
	MOV 	AL, OFFSET FIN_M-OFFSET MSJ
	INT 	7
	CALL	CONTRA
	CMP	DH, 0FFH
	JNZ	ELSE
	MOV 	BX, OFFSET PERM
	MOV 	AL, OFFSET FIN_PE - OFFSET PERM
	INT 	7 
	JMP 	FIN 
ELSE:	MOV 	BX, OFFSET DENEG
	MOV 	AL, OFFSET FIN_DE - OFFSET DENEG
	INT 	7
FIN:	INT 	0
	END


