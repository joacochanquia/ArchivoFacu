PIC 	EQU 	20H
EOI 	EQU 	20H
N_F10 	EQU 	10
	ORG 	40
IP_F10 	DW 	RUT_F10

	ORG	1000H
CHAR	DB	41H

	ORG 	2000H
	CLI
	MOV 	AL, 0FEH
	OUT 	PIC+1, AL ; PIC: registro IMR
	MOV 	AL, N_F10
	OUT 	PIC+4, AL ; PIC: registro INT0
	MOV 	DX, 0
	MOV	AH, 41H
	STI

LAZO: 	CMP	DH, 01H
	JZ	IMP
	CMP	AH, 5BH
	JNZ	LETRA
	MOV	AH, 41H
	JMP	LAZO
LETRA:	INC	AH
	JMP 	LAZO

IMP:	CLI
	MOV	BX, OFFSET CHAR
	MOV	[BX], AH
	MOV	AL, 1
	INT	7
	INT	0
	STI

	ORG 	3000H
RUT_F10:PUSH 	AX
	MOV	DH, 01H
	MOV 	AL, EOI
	OUT 	EOI, AL ; PIC: registro EOI
	POP 	AX
	IRET
	END
