	ORG 	1000H
MSJ 	DB 	"INGRESE UN NUMERO:"
FIN_M 	DB 	?
MSJ2 	DB 	"CARACTER NO VALIDO"
FIN_M2 	DB 	?
	ORG 	1500H
NUM 	DB 	?
	ORG	3000H
ES_NUM:	MOV	CH, 30H
LAZO:	CMP	CL, CH
	JZ	SI_ES
	INC	CH
	CMP	CH, 3AH
	JNZ	LAZO
	MOV	CH, 00H
	JMP	FIN_S
SI_ES:	MOV	CH, 0FFH
FIN_S:	RET
	ORG 	2000H
	MOV 	BX, OFFSET MSJ
	MOV 	AL, OFFSET FIN_M-OFFSET MSJ
	INT 	7
	MOV 	BX, OFFSET NUM
	INT 	6
	MOV 	AL, 1
	INT 	7
	MOV 	CL, NUM
	CALL	ES_NUM
	CMP	CH, 0FFH
	JZ	FIN
	MOV 	BX, OFFSET MSJ2
	MOV 	AL, OFFSET FIN_M2-OFFSET MSJ2
	INT 	7
FIN:	INT 	0
	END
