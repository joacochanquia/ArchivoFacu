HAND 	EQU 	40H
	ORG 	1000H
MSJ 	DB 	"Ingrese caracteres:"
FINMSJ	DB	?
	ORG	1500H
CHARS	DB	"*****"
	ORG 	2000H
	IN 	AL, HAND+1
	AND 	AL, 7FH
	OUT 	HAND+1, AL
	MOV 	BX, OFFSET MSJ
	MOV 	AL, OFFSET FINMSJ-OFFSET MSJ
	INT 	7
	MOV	DH, 5
	MOV 	BX, OFFSET CHARS
INCHARS:INT 	6
	MOV 	AL, 1
	INT 	7
	INC 	BX 
	DEC 	DH
	JNZ 	INCHARS 
	MOV	BX, OFFSET CHARS
	MOV	CL, 5
POLL: 	IN 	AL, HAND+1
	AND	AL, 1
	JNZ 	POLL
	MOV 	AL, [BX]
	OUT 	HAND, AL
	INC 	BX
	DEC 	CL
	JNZ 	POLL
	MOV	CL, 5
	DEC	BX
POLL2: 	IN 	AL, HAND+1
	AND	AL, 1
	JNZ 	POLL2
	MOV 	AL, [BX]
	OUT 	HAND, AL
	DEC 	BX
	DEC 	CL
	JNZ 	POLL2
	INT 	0
	END
